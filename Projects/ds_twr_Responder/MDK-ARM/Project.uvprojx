# Keil uVision project Project.uvprojx, settings and files
target STM32F042 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F042G6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x1800) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F042
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F042,SE_DEFAULT_TIMEOUT_CALLBACK
  c misc: --c99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\Include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32F0xx_CPAL_Driver\inc;..\..\..\Libraries\CMSIS\Include;..\inc;..\..\..\Libraries\STM32_USB_Device_Driver\inc;..\..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc;..\..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\deca_driver;..\deca_driver\port;..\SystemConfig;..\RTLS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --diag_suppress=L6329
  group CMSIS
    ../../../Libraries/CMSIS/Device/Source/startup/: startup_stm32f042.s
    ../: system_stm32f0xx.c
  group User
    ../: main.c stm32f0xx_it.c
    ../src/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_pwr.c usbd_usr.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_syscfg.c stm32f0xx_spi.c stm32f0xx_usart.c stm32f0xx_rcc.c stm32f0xx_dma.c stm32f0xx_gpio.c stm32f0xx_can.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_tim.c stm32f0xx_crc.c stm32f0xx_crs.c
  group Driver
    ../src/: LED.c TimerCounter.c Delay.c DW1000.c TaskTimer.c
  group Middlewares
    ../src/: Maths.c CRC16.c DataMonitor.c CommProtocol.c
    ../RTLS/: ds_resp_main.c
  group USB_Class
    ../../../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB_Drivers
    ../../../Libraries/STM32_USB_Device_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_Library
    ../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group decaDriver
    ../deca_driver/: deca_device.c deca_params_init.c
    ../deca_driver/port/: port_platform.c
