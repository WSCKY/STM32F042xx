# Keil uVision project Project.uvprojx, settings and files
target STM32F042 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F042G6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x1800) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F042
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F042,SE_DEFAULT_TIMEOUT_CALLBACK
  c misc: --c99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\Include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32F0xx_CPAL_Driver\inc;..\..\..\Libraries\CMSIS\Include;..\inc;..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --diag_suppress=L6329
  group CMSIS
    ../../../Libraries/CMSIS/Device/Source/startup/: startup_stm32f042.s
    ../: system_stm32f0xx.c
  group User
    ../: main.c stm32f0xx_it.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_rcc.c stm32f0xx_dma.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_tim.c stm32f0xx_adc.c
  group Driver
    ../src/: Delay.c TimerCounter.c PWR_CTRL.c UserButton.c WS2812B.c TouchPad.c ADC.c
  group Middlewares
    ../src/: Maths.c CRC16.c
    ../App/: LightMode.c ColorSelector.c KeyUI.c CurveCtrl.c
